/*
 * SNIFF - TinyML gas detector with Wi-Fi dashboard
 * Author: Ayaan Khan
 *
 * Implements the full output stage of Figure 1 in the project proposal:
 *   Sensing    MQ-6 + DHT22 -> ADC
 *   Processing ESP32 data acquisition and feature extraction
 *   Inference  TinyML model (TensorFlow Lite Micro), safe vs gas leak
 *   Output     Alarm (LED + buzzer), Safe state (green LED), IoT alert (Wi-Fi)
 *
 * The board raises its own Wi-Fi access point, so the dashboard works with
 * no router, no internet and no credentials. Connect a phone or laptop to
 *     SSID  SNIFF-Detector
 *     pass  sniffgas2026
 * and open  http://192.168.4.1
 *
 * The page shows the model's verdict beside the conventional fixed-threshold
 * verdict, which is the comparison the project exists to make.
 *
 * Pin map (as wired):
 *   GPIO34  MQ-6 AOUT through a 10k/10k divider   (ADC1; ADC2 dies with Wi-Fi)
 *   GPIO27  DHT22 data
 *   GPIO26  DHT22 power, held HIGH
 *   GPIO33  red LED   + 220R
 *   GPIO25  green LED + 220R
 *   GPIO13  active buzzer
 *
 * Library needed (Arduino Library Manager): "TensorFlowLite_ESP32"
 */

#include <WiFi.h>
#include <WebServer.h>
#include <DHT.h>
#include <Preferences.h>

#include <Chirale_TensorFlowLite.h>
#include "tensorflow/lite/micro/micro_interpreter.h"
#include "tensorflow/lite/micro/micro_mutable_op_resolver.h"
#include "tensorflow/lite/schema/schema_generated.h"

#include "model_data.h"

// ------------------------------------------------------------ pins
#define MQ_PIN      34
#define DHT_PIN     27
#define DHT_PWR     26
#define LED_ALARM   33
#define LED_SAFE    25
#define BUZZER_PIN  13

// ------------------------------------------------------------ constants
const char *AP_SSID = "SNIFF-Detector";
const char *AP_PASS = "sniffgas2026";

const float VC = 5.0f;
const float RL_KOHM = 10.0f;        // MEASURE YOURS
const float DIVIDER_RATIO = 2.0f;

const int   ADC_SAMPLES = 32;
const int   SLOPE_WINDOW = 10;
const unsigned long LOOP_MS = 1000;
const unsigned long DHT_MIN_MS = 2000;

// The conventional detectors' constants are GENERATED by train_tflite.py into
// model_data.h, refitted on the full dataset. They are not hand-set here, so
// the firmware cannot drift out of sync with the analysis.
//
//   Detector 1, fixed threshold : alarm when rs_ro < SNIFF_FIXED_T
//   Detector 2, compensated     : expected = A + B*T + C*RH
//                                 alarm when (rs_ro - expected) < SNIFF_COMP_T
//
// Detector 2 is the one that beat both the fixed threshold and the network on
// held-out sessions, so the dashboard shows all three side by side.
// The conventional detector self-calibrates, like a real one. It averages
// clean air after warm-up and trips at SNIFF_FIXED_FRAC of that baseline.
// An absolute trip point does not survive MQ-6 drift: this unit's clean-air
// reading moved 1.43 -> 1.76 overnight, more than the humidity effect itself.
const int   CONFIRM_SAMPLES = 3;          // debounce before latching the alarm

// Power-on warm-up lockout.
// The MQ-6's sensing element must reach operating temperature before Rs means
// anything. Cold, its resistance sits far below Ro, so rs_ro looks like a
// large gas concentration and every detector calls a leak. Commercial units
// suppress the alarm through this window for the same reason. Readings are
// still computed, served and printed during warm-up; only the outputs wait.
const unsigned long WARMUP_MS = 90000;

const unsigned long CAL_AFTER_MS = WARMUP_MS + 20000;  // settle, then sample
const unsigned long CAL_SPAN_MS  = 20000;              // 20 s average
float convBase   = 0.0f;      // clean-air baseline, 0 until calibrated
float convAcc    = 0.0f;      // accumulator while sampling
int   convN      = 0;
bool  convDone   = false;

const int   HIST = 120;                   // seconds of history for the chart

// ------------------------------------------------------------ globals
DHT dht(DHT_PIN, DHT22);
Preferences prefs;
WebServer server(80);

float Ro_kohm = 0.0f;
float rsWindow[SLOPE_WINDOW];
int   wIdx = 0;
bool  wFull = false;

float lastTemp = NAN, lastRH = NAN;
unsigned long lastDht = 0, lastLoop = 0;
int  leakStreak = 0;
bool muted = false;

float  curRsRo = NAN, curSlope = 0, curConf = 0;
bool   curAlarm = false, curThresh = false, curComp = false;
bool   curModelRaw = false;     // model's per-sample call, before debounce

// Which detector arms the alarm. BOTH always run and both verdicts are always
// shown; this only selects which one drives the buzzer and LEDs, so the demo
// compares decision rules on identical live data rather than swapping
// firmware. 0 = conventional fixed threshold, 1 = SNIFF model.
volatile int alarmMode = 1;
unsigned long testUntil = 0;   // alarm self-test expiry
float  curResid = 0.0f;   // rs_ro minus its temperature/humidity expectation
float  convTrip = 0.0f;   // conventional detector's live trip point
uint32_t sampleCount = 0;

// Counts page and data requests served. Printed with the access-point status
// so a failed demo can be diagnosed in one line: clients=0 means the phone
// never associated at the radio level, clients=1 with hits climbing means the
// page is being served and the problem is elsewhere.
volatile uint32_t httpHits = 0;

float  hist[HIST];
int    histN = 0, histHead = 0;

// ------------------------------------------------------------ TFLM
namespace {
  const tflite::Model *model = nullptr;
  tflite::MicroInterpreter *interpreter = nullptr;
  TfLiteTensor *inTensor = nullptr;
  TfLiteTensor *outTensor = nullptr;
  constexpr int kArenaSize = 16 * 1024;
  alignas(16) uint8_t arena[kArenaSize];
}

static bool tfliteReady = false;

static void setupModel() {
  model = tflite::GetModel(sniff_model_tflite);
  if (model->version() != TFLITE_SCHEMA_VERSION) {
    Serial.printf("# model schema %lu != supported %d\n",
                  (unsigned long)model->version(), TFLITE_SCHEMA_VERSION);
    return;
  }
  // Only the operators this network uses, which keeps the binary small.
  static tflite::MicroMutableOpResolver<4> resolver;
  resolver.AddFullyConnected();
  resolver.AddSoftmax();
  resolver.AddQuantize();
  resolver.AddDequantize();

  static tflite::MicroInterpreter si(model, resolver, arena, kArenaSize);
  interpreter = &si;
  if (interpreter->AllocateTensors() != kTfLiteOk) {
    Serial.println(F("# AllocateTensors failed"));
    return;
  }
  inTensor  = interpreter->input(0);
  outTensor = interpreter->output(0);
  tfliteReady = true;
  Serial.printf("# TFLite Micro ready. arena used %u of %d bytes\n",
                (unsigned)interpreter->arena_used_bytes(), kArenaSize);
}

/* Normalise, quantise, invoke, dequantise. Returns true for leak. */
static bool runModel(const float *feat, float *conf) {
  if (!tfliteReady) { *conf = 0; return false; }

  const float iScale = inTensor->params.scale;
  const int   iZero  = inTensor->params.zero_point;

  for (int i = 0; i < SNIFF_N_FEATURES; i++) {
    float z = (feat[i] - SNIFF_FEAT_MEAN[i]) / SNIFF_FEAT_STD[i];
    int q = (int)lroundf(z / iScale) + iZero;
    if (q < -128) q = -128;
    if (q >  127) q =  127;
    inTensor->data.int8[i] = (int8_t)q;
  }

  if (interpreter->Invoke() != kTfLiteOk) { *conf = 0; return false; }

  const float oScale = outTensor->params.scale;
  const int   oZero  = outTensor->params.zero_point;
  float pSafe = (outTensor->data.int8[0] - oZero) * oScale;
  float pLeak = (outTensor->data.int8[1] - oZero) * oScale;
  *conf = pLeak;
  return pLeak > pSafe;
}

// ------------------------------------------------------------ sensing
static float readAoutVolts() {
  uint32_t acc = 0;
  for (int i = 0; i < ADC_SAMPLES; i++) {
    acc += analogReadMilliVolts(MQ_PIN);
    delayMicroseconds(200);
  }
  return ((acc / (float)ADC_SAMPLES) / 1000.0f) * DIVIDER_RATIO;
}

static float computeRs(float v) {
  if (v <= 0.01f) return NAN;
  if (v >= VC - 0.01f) return 0.0f;
  return RL_KOHM * (VC - v) / v;
}

static float computeSlope(float rs) {
  rsWindow[wIdx] = rs;
  int oldest = (wIdx + 1) % SLOPE_WINDOW;
  wIdx = (wIdx + 1) % SLOPE_WINDOW;
  if (wIdx == 0) wFull = true;
  if (!wFull) return 0.0f;
  return (rs - rsWindow[oldest]) / (float)(SLOPE_WINDOW - 1);
}

static void calibrateRo() {
  Serial.println(F("# calibrating Ro. Clean air, 60 s."));
  float acc = 0; int n = 0;
  for (int i = 0; i < 60; i++) {
    float rs = computeRs(readAoutVolts());
    if (!isnan(rs) && rs > 0) { acc += rs; n++; }
    Serial.printf("# %2d/60  Rs = %.2f kohm\n", i + 1, rs);
    delay(1000);
  }
  if (!n) { Serial.println(F("# FAILED: check the 5 V heater rail.")); return; }
  Ro_kohm = acc / n;
  prefs.begin("sniff", false); prefs.putFloat("ro", Ro_kohm); prefs.end();
  Serial.printf("# Ro = %.2f kohm, saved\n", Ro_kohm);
}

// ------------------------------------------------------------ web
// A conventional domestic gas detector, implemented faithfully.
//
// This is NOT a copy of any manufacturer's firmware. It is the METHOD those
// units use: a single gas-sensor reading compared against a single fixed
// trip point, with no temperature or humidity input. The page deliberately
// shows nothing else, because a detector built this way has nothing else to
// show. That information poverty is the point being demonstrated.
static const char STYLE[] PROGMEM = R"CSS(
*{box-sizing:border-box;-webkit-tap-highlight-color:transparent}
:root{--ink:#082a3f;--mut:#5d87a1;--pink:#ff2d7a;--pinkd:#d2145a;
--card:rgba(255,255,255,.78);--line:rgba(8,42,63,.09)}
html,body{margin:0;height:100%}
body{font:16px/1.45 -apple-system,BlinkMacSystemFont,"Segoe UI",Inter,Roboto,sans-serif;
color:var(--ink);background:linear-gradient(170deg,#eaf7ff 0%,#c2e6fb 46%,#9ed5f6 100%);
background-attachment:fixed;min-height:100%}
.w{max-width:560px;margin:0 auto;padding:26px 20px 34px}
.top{display:flex;align-items:center;justify-content:space-between;margin-bottom:30px}
.bd{font-weight:650;letter-spacing:-.3px;font-size:17px}
.bd s{text-decoration:none;color:var(--pink)}
.live{font-size:11px;color:var(--mut);letter-spacing:.3px}
.live i{display:inline-block;width:6px;height:6px;border-radius:50%;
background:var(--pink);margin-right:5px;vertical-align:1px}
.hero{background:var(--card);backdrop-filter:blur(18px);-webkit-backdrop-filter:blur(18px);
border:1px solid rgba(255,255,255,.75);border-radius:26px;padding:40px 26px;text-align:center;
box-shadow:0 18px 50px -22px rgba(8,42,63,.45);margin-bottom:14px}
.st{font-size:62px;font-weight:680;letter-spacing:-2.5px;line-height:1}
.st.bad{color:var(--pink)}
.cap{font-size:12.5px;color:var(--mut);margin-top:12px;letter-spacing:.2px}
.row{display:flex;gap:10px;margin-bottom:14px}
.cell{flex:1;background:var(--card);backdrop-filter:blur(18px);
-webkit-backdrop-filter:blur(18px);border:1px solid rgba(255,255,255,.75);
border-radius:18px;padding:15px 14px;box-shadow:0 10px 30px -20px rgba(8,42,63,.5)}
.k{font-size:10.5px;color:var(--mut);text-transform:uppercase;letter-spacing:.9px}
.v{font-size:24px;font-weight:620;letter-spacing:-.8px;margin-top:4px}
.v u{text-decoration:none;font-size:12px;color:var(--mut);font-weight:400;letter-spacing:0}
.v.bad{color:var(--pink)}
.pill{display:flex;gap:8px;margin-bottom:14px}
.p{flex:1;background:var(--card);border:1px solid rgba(255,255,255,.75);border-radius:14px;
padding:11px 10px;text-align:center;box-shadow:0 10px 30px -22px rgba(8,42,63,.5)}
.p b{display:block;font-size:10px;color:var(--mut);text-transform:uppercase;
letter-spacing:.8px;font-weight:600}
.p span{display:block;font-size:16px;font-weight:620;margin-top:4px;letter-spacing:-.3px}
.p span.bad{color:var(--pink)}
.card{background:var(--card);backdrop-filter:blur(18px);-webkit-backdrop-filter:blur(18px);
border:1px solid rgba(255,255,255,.75);border-radius:18px;padding:14px;margin-bottom:14px;
box-shadow:0 10px 30px -20px rgba(8,42,63,.5)}
canvas{width:100%;height:112px;display:block}
.nt{font-size:12.5px;color:var(--mut);line-height:1.65}
.nt b{color:var(--ink);font-weight:600}
a.btn{display:block;text-align:center;text-decoration:none;padding:15px;border-radius:16px;
background:var(--pink);color:#fff;font-weight:620;font-size:14.5px;letter-spacing:-.2px;
box-shadow:0 14px 34px -14px rgba(255,45,122,.8)}
a.gho{background:rgba(255,255,255,.72);color:var(--ink);box-shadow:none;
border:1px solid rgba(255,255,255,.9)}
.grp{font-size:10.5px;color:var(--mut);text-transform:uppercase;letter-spacing:.9px;
margin:2px 0 8px 4px}
.vs2{display:flex;gap:10px;margin-bottom:14px}
.vs2 .pane{flex:1;background:var(--card);backdrop-filter:blur(18px);
-webkit-backdrop-filter:blur(18px);border:1px solid rgba(255,255,255,.75);border-radius:20px;
padding:22px 14px;text-align:center;box-shadow:0 14px 38px -22px rgba(8,42,63,.5)}
.pane h2{margin:0 0 14px;font-size:11px;color:var(--mut);text-transform:uppercase;
letter-spacing:.9px;font-weight:600}
.pane .s{font-size:34px;font-weight:680;letter-spacing:-1.3px;line-height:1}
.pane .s.bad{color:var(--pink)}
.pane em{display:block;font-style:normal;font-size:11px;color:var(--mut);margin-top:9px}
.arm{font-size:11.5px;color:var(--mut);text-align:center;margin:-4px 0 14px}
)CSS";

static const char PAGE_CONV[] PROGMEM = R"HTML(<!doctype html><html><head>
<meta charset="utf-8"><meta name="viewport" content="width=device-width,initial-scale=1">
<title>Gas Detector</title><link rel="stylesheet" href="/s.css"></head><body><div class="w">
<div class="top"><div class="bd">Gas Detector</div>
<div class="live"><i></i><span id="sts">live</span></div></div>

<div class="hero"><div class="st" id="v">&mdash;</div>
<div class="cap" id="cap">&nbsp;</div></div>

<div class="row">
<div class="cell"><div class="k">Sensor vs clean air</div><div class="v"><span id="pc">&mdash;</span> <u>%</u></div></div>
<div class="cell"><div class="k">Alarms below</div><div class="v"><span id="pt">&mdash;</span> <u>%</u></div></div>
</div>

<div class="grp"><span id="cal">&nbsp;</span></div>
<div class="grp">Ambient &mdash; not used by this detector</div>
<div class="row">
<div class="cell"><div class="k">Temp</div><div class="v"><span id="tp">&mdash;</span> <u>&deg;C</u></div></div>
<div class="cell"><div class="k">Humidity</div><div class="v"><span id="hu">&mdash;</span> <u>%</u></div></div>
</div>

<div class="row">
<a class="btn" href="/sniff" style="flex:1">SNIFF</a>
<a class="btn gho" href="/both" style="flex:1">Side by side</a>
</div>
<div class="row"><a class="btn gho" href="#" onclick="fetch('/cal');return false" style="flex:1">Recalibrate in clean air</a></div>
</div><script>
function t(){fetch('/d').then(function(r){return r.json()}).then(function(d){
var e=document.getElementById('v');
e.textContent=d.th?'LEAK':'SAFE';e.className='st'+(d.th?' bad':'');
document.getElementById('cap').textContent=d.th?'alarm sounding':'no gas detected';
var pct=d.bs>0.01?d.rr/d.bs*100:100, ptr=d.bs>0.01?d.ft/d.bs*100:100;
document.getElementById('pc').textContent=pct.toFixed(1);
document.getElementById('pt').textContent=ptr.toFixed(1);
document.getElementById('tp').textContent=d.t.toFixed(1);
document.getElementById('hu').textContent=d.h.toFixed(0);
document.getElementById('sts').textContent='live';
document.getElementById('cal').textContent=d.cb?'CALIBRATED IN CLEAN AIR':'SAMPLING CLEAN AIR\u2026';
}).catch(function(){document.getElementById('sts').textContent='offline'})}
t();setInterval(t,1000);
</script></body></html>)HTML";

static const char PAGE_BOTH[] PROGMEM = R"HTML(<!doctype html><html><head>
<meta charset="utf-8"><meta name="viewport" content="width=device-width,initial-scale=1">
<title>Side by side</title><link rel="stylesheet" href="/s.css"></head><body><div class="w">
<div class="top"><div class="bd"><s>&#9679;</s> Side by side</div>
<div class="live"><i></i><span id="sts">live</span></div></div>

<div class="vs2">
<div class="pane"><h2>Conventional</h2><div class="s" id="cv">&mdash;</div>
<em id="ce">&nbsp;</em></div>
<div class="pane"><h2>SNIFF</h2><div class="s" id="sv">&mdash;</div>
<em id="se">&nbsp;</em></div>
</div>
<div class="arm">Buzzer follows SNIFF on this page</div>

<div class="row">
<div class="cell"><div class="k">Sensor vs clean air</div><div class="v"><span id="pc">&mdash;</span> <u>%</u></div></div>
<div class="cell"><div class="k">Temp</div><div class="v"><span id="tp">&mdash;</span> <u>&deg;C</u></div></div>
<div class="cell"><div class="k">Humidity</div><div class="v"><span id="hu">&mdash;</span> <u>%</u></div></div>
</div>

<div class="card"><canvas id="c" width="560" height="112"></canvas></div>

<div class="row">
<a class="btn gho" href="/" style="flex:1">Conventional</a>
<a class="btn gho" href="/sniff" style="flex:1">SNIFF</a>
</div>
</div><script>
var H=[],N=110,TH=1;
function px(i){var c=document.getElementById('c');return i*(c.width/(N-1))}
function draw(){var c=document.getElementById('c'),x=c.getContext('2d'),W=c.width,Y=c.height;
x.clearRect(0,0,W,Y);if(H.length<2)return;
var mn=Math.min.apply(null,H),mx=Math.max.apply(null,H);
mn=Math.min(mn,TH)-.06;mx=Math.max(mx,TH)+.06;
function py(v){return Y-6-(v-mn)/(mx-mn)*(Y-14)}
var ty=py(TH);
if(ty>0&&ty<Y){x.strokeStyle='rgba(255,45,122,.6)';x.lineWidth=1.5;x.setLineDash([5,5]);
x.beginPath();x.moveTo(0,ty);x.lineTo(W,ty);x.stroke();x.setLineDash([])}
x.strokeStyle='#0b7fd4';x.lineWidth=2.2;x.lineJoin='round';x.beginPath();
for(var i=0;i<H.length;i++){var X=px(i+N-H.length),V=py(H[i]);i?x.lineTo(X,V):x.moveTo(X,V)}
x.stroke();
x.fillStyle='#0b7fd4';x.beginPath();x.arc(px(N-1),py(H[H.length-1]),3.4,0,6.3);x.fill()}
function t(){fetch('/d').then(function(r){return r.json()}).then(function(d){
var a=document.getElementById('cv'),b=document.getElementById('sv');
a.textContent=d.th?'LEAK':'SAFE';a.className='s'+(d.th?' bad':'');
b.textContent=d.ai?'LEAK':'SAFE';b.className='s'+(d.ai?' bad':'');
var ptr=d.bs>0.01?d.ft/d.bs*100:100;
document.getElementById('ce').textContent='alarms below '+ptr.toFixed(1)+'% of clean air';
document.getElementById('se').textContent='uses temp + humidity';
document.getElementById('pc').textContent=(d.bs>0.01?d.rr/d.bs*100:100).toFixed(1);
document.getElementById('tp').textContent=d.t.toFixed(1);
document.getElementById('hu').textContent=d.h.toFixed(0);
document.getElementById('sts').textContent='live';
if(d.ft)TH=d.ft;
H.push(d.rr);if(H.length>N)H.shift();draw();
}).catch(function(){document.getElementById('sts').textContent='offline'})}
t();setInterval(t,1000);
</script></body></html>)HTML";



static const char PAGE[] PROGMEM = R"HTML(<!doctype html><html><head>
<meta charset="utf-8"><meta name="viewport" content="width=device-width,initial-scale=1">
<title>SNIFF</title><link rel="stylesheet" href="/s.css"></head><body><div class="w">
<div class="top"><div class="bd"><s>&#9679;</s> SNIFF</div>
<div class="live"><i></i><span id="sts">live</span></div></div>

<div class="hero"><div class="st" id="v">&mdash;</div>
<div class="cap" id="cap">&nbsp;</div></div>

<div class="pill">
<div class="p"><b>Model</b><span id="aiv">&mdash;</span></div>
<div class="p"><b>Fixed</b><span id="thv">&mdash;</span></div>
<div class="p"><b>Compensated</b><span id="cpv">&mdash;</span></div>
</div>

<div class="row">
<div class="cell"><div class="k">Sensor vs clean air</div><div class="v"><span id="pc">&mdash;</span> <u>%</u></div></div>
<div class="cell"><div class="k">Temp</div><div class="v"><span id="tp">&mdash;</span> <u>&deg;C</u></div></div>
<div class="cell"><div class="k">Humidity</div><div class="v"><span id="hu">&mdash;</span> <u>%</u></div></div>
</div>

<div class="card"><canvas id="c" width="560" height="112"></canvas></div>

<div class="row">
<a class="btn gho" href="/" style="flex:1">Conventional</a>
<a class="btn gho" href="/both" style="flex:1">Side by side</a>
</div>
</div><script>
var H=[],N=110,TH=1;
function px(i){var c=document.getElementById('c');return i*(c.width/(N-1))}
function draw(){var c=document.getElementById('c'),x=c.getContext('2d'),W=c.width,Y=c.height;
x.clearRect(0,0,W,Y);if(H.length<2)return;
var mn=Math.min.apply(null,H),mx=Math.max.apply(null,H);
mn=Math.min(mn,TH)-.06;mx=Math.max(mx,TH)+.06;
function py(v){return Y-6-(v-mn)/(mx-mn)*(Y-14)}
var ty=py(TH);
if(ty>0&&ty<Y){x.strokeStyle='rgba(255,45,122,.55)';x.lineWidth=1.5;x.setLineDash([5,5]);
x.beginPath();x.moveTo(0,ty);x.lineTo(W,ty);x.stroke();x.setLineDash([])}
var g=x.createLinearGradient(0,0,0,Y);
g.addColorStop(0,'rgba(11,127,212,.22)');g.addColorStop(1,'rgba(11,127,212,0)');
x.beginPath();for(var i=0;i<H.length;i++){var X=px(i+N-H.length),V=py(H[i]);i?x.lineTo(X,V):x.moveTo(X,V)}
x.lineTo(px(N-1),Y);x.lineTo(px(N-H.length),Y);x.closePath();x.fillStyle=g;x.fill();
x.strokeStyle='#0b7fd4';x.lineWidth=2.2;x.lineJoin='round';x.beginPath();
for(var i=0;i<H.length;i++){var X=px(i+N-H.length),V=py(H[i]);i?x.lineTo(X,V):x.moveTo(X,V)}
x.stroke();
x.fillStyle='#0b7fd4';x.beginPath();x.arc(px(N-1),py(H[H.length-1]),3.4,0,6.3);x.fill()}
function set(id,on){var e=document.getElementById(id);
e.textContent=on?'Leak':'Safe';e.className=on?'bad':''}
function t(){fetch('/d').then(function(r){return r.json()}).then(function(d){
var e=document.getElementById('v');
e.textContent=d.ai?'LEAK':'SAFE';e.className='st'+(d.ai?' bad':'');
document.getElementById('cap').textContent=d.ai?'alarm sounding':'no gas detected';
set('aiv',d.ai);set('thv',d.th);set('cpv',d.cp);
document.getElementById('pc').textContent=(d.bs>0.01?d.rr/d.bs*100:100).toFixed(1);
document.getElementById('tp').textContent=d.t.toFixed(1);
document.getElementById('hu').textContent=d.h.toFixed(0);
document.getElementById('sts').textContent='live';
if(d.ft)TH=d.ft;
H.push(d.rr);if(H.length>N)H.shift();draw();
}).catch(function(){document.getElementById('sts').textContent='offline'})}
t();setInterval(t,1000);
</script></body></html>)HTML";



static void handleData() {
  httpHits++;
  char b[320];
  snprintf(b, sizeof(b),
    "{\"rr\":%.4f,\"t\":%.2f,\"h\":%.2f,\"d\":%.5f,"
    "\"ai\":%d,\"conf\":%.4f,\"th\":%d,\"cp\":%d,\"rsd\":%.4f,\"ft\":%.4f,\"md\":%d,\"cb\":%d,\"bs\":%.4f,\"ro\":%.2f,\"n\":%lu}",
    isnan(curRsRo) ? 0.0f : curRsRo,
    isnan(lastTemp) ? 0.0f : lastTemp,
    isnan(lastRH) ? 0.0f : lastRH,
    curSlope, curAlarm ? 1 : 0, curConf, curThresh ? 1 : 0, curComp ? 1 : 0,
    curResid, (double)convTrip, alarmMode, convDone ? 1 : 0, (double)convBase, Ro_kohm, (unsigned long)sampleCount);
  server.send(200, "application/json", b);
}

// ------------------------------------------------------------ setup
void setup() {
  Serial.begin(115200);
  delay(400);

  pinMode(DHT_PWR, OUTPUT); digitalWrite(DHT_PWR, HIGH); delay(100);
  pinMode(LED_ALARM, OUTPUT); pinMode(LED_SAFE, OUTPUT); pinMode(BUZZER_PIN, OUTPUT);
  digitalWrite(LED_ALARM, LOW); digitalWrite(LED_SAFE, LOW); digitalWrite(BUZZER_PIN, LOW);

  // ADC1 is mandatory here: ADC2 is taken over by the Wi-Fi driver, and this
  // build runs Wi-Fi, so the gas channel has to be on GPIO32-39.
  analogSetPinAttenuation(MQ_PIN, ADC_11db);
  dht.begin();

  prefs.begin("sniff", true); Ro_kohm = prefs.getFloat("ro", 0.0f); prefs.end();
  for (int i = 0; i < SLOPE_WINDOW; i++) rsWindow[i] = 0.0f;

  Serial.println(F("\n# SNIFF - TinyML gas detector with Wi-Fi dashboard"));
  setupModel();
  if (Ro_kohm <= 0) Serial.println(F("# WARNING: Ro not calibrated. Send 'c' in clean air."));
  else Serial.printf("# Ro = %.2f kohm\n", Ro_kohm);

  WiFi.mode(WIFI_AP);
  WiFi.softAP(AP_SSID, AP_PASS);
  Serial.printf("# Wi-Fi AP \"%s\"  password \"%s\"\n", AP_SSID, AP_PASS);
  Serial.print(F("# dashboard: http://")); Serial.println(WiFi.softAPIP());

  // "/" is the conventional detector. Loading a page arms that page's rule,
  // so walking from one page to the other is the comparison.
  server.on("/", []() {
    httpHits++; alarmMode = 0; leakStreak = 0;
    server.send_P(200, "text/html", PAGE_CONV);
  });
  server.on("/cal", []() {
    convAcc = 0; convN = 0; convBase = 0; convDone = false;
    Serial.println(F("# conventional detector: re-sampling clean air"));
    server.send(200, "text/plain", "ok");
  });
  server.on("/both", []() {
    httpHits++; alarmMode = 1; leakStreak = 0;
    server.send_P(200, "text/html", PAGE_BOTH);
  });
  server.on("/sniff", []() {
    httpHits++; alarmMode = 1; leakStreak = 0;
    server.send_P(200, "text/html", PAGE);
  });
  server.on("/m", []() {
    if (server.hasArg("v")) {
      alarmMode = server.arg("v").toInt() ? 1 : 0;
      leakStreak = 0;                       // do not carry a streak across modes
      Serial.printf("# alarm armed by: %s\n",
                    alarmMode ? "SNIFF model" : "conventional fixed threshold");
    }
    server.send(200, "text/plain", alarmMode ? "1" : "0");
  });
  server.on("/s.css", []() {
    server.sendHeader("Cache-Control", "max-age=86400");
    server.send_P(200, "text/css", STYLE);
  });
  server.on("/d", handleData);
  server.begin();

  Serial.println(F("# rs_ro,temp_c,rh_pct,drs_dt,model,confidence,fixed_says,compensated_says"));
}

// ------------------------------------------------------------ loop
void loop() {
  server.handleClient();

  if (Serial.available()) {
    char c = Serial.read();
    if (c == 'c') calibrateRo();
    else if (c == 'r') Serial.printf("# Ro = %.2f kohm\n", Ro_kohm);
    else if (c == 'm') { muted = !muted; Serial.printf("# muted=%d\n", muted); }
    else if (c == 'b') {
      convAcc = 0; convN = 0; convBase = 0; convDone = false;
      Serial.println(F("# conventional detector: re-sampling clean air"));
    }
    else if (c == 't') {
      // Exercises the whole output stage without needing gas.
      testUntil = millis() + 4000;
      digitalWrite(LED_ALARM, HIGH);
      digitalWrite(LED_SAFE, LOW);
      if (!muted) digitalWrite(BUZZER_PIN, HIGH);
      Serial.println(F("# SELF-TEST: alarm asserted for 4 s"));
    }
  }

  // End the self-test promptly rather than on the next 1 Hz tick.
  if (testUntil && millis() >= testUntil) {
    testUntil = 0;
    bool a = curAlarm && (millis() >= WARMUP_MS);
    digitalWrite(LED_ALARM, a ? HIGH : LOW);
    digitalWrite(LED_SAFE,  a ? LOW  : HIGH);
    digitalWrite(BUZZER_PIN, (a && !muted) ? HIGH : LOW);
    Serial.println(F("# SELF-TEST complete, outputs restored"));
  }

  unsigned long now = millis();
  if (now - lastLoop < LOOP_MS) return;
  lastLoop = now;

  if (now - lastDht >= DHT_MIN_MS) {
    float t = dht.readTemperature(), h = dht.readHumidity();
    if (!isnan(t)) lastTemp = t;
    if (!isnan(h)) lastRH = h;
    lastDht = now;
  }

  float rs = computeRs(readAoutVolts());
  if (isnan(rs) || Ro_kohm <= 0 || isnan(lastTemp) || isnan(lastRH)) {
    Serial.println(F("# waiting for valid sensor data"));
    return;
  }

  curRsRo  = rs / Ro_kohm;
  curSlope = computeSlope(rs);

  float feat[SNIFF_N_FEATURES] = { curRsRo, lastTemp, lastRH, curSlope };
  bool leak = runModel(feat, &curConf);

  curModelRaw = leak;
  // Gather the clean-air baseline, then apply the fractional trip point.
  if (!convDone && millis() >= CAL_AFTER_MS) {
    convAcc += curRsRo; convN++;
    convBase = convAcc / convN;
    if (millis() >= CAL_AFTER_MS + CAL_SPAN_MS && convN >= 10) {
      convDone = true;
      Serial.printf("# conventional detector calibrated: clean air %.3f, "
                    "trips below %.3f\n", convBase, convBase * SNIFF_FIXED_FRAC);
    }
  }
  convTrip = (convBase > 0.01f) ? convBase * SNIFF_FIXED_FRAC
                                : (float)SNIFF_FIXED_T;
  curThresh   = (curRsRo < convTrip);

  // Compensated detector: compare Rs/Ro against what clean air SHOULD read at
  // this temperature and humidity, rather than against a constant.
  float expected = SNIFF_COMP_A + SNIFF_COMP_B * lastTemp + SNIFF_COMP_C * lastRH;
  curResid = curRsRo - expected;
  curComp  = (curResid < SNIFF_COMP_T);
  sampleCount++;

  // Debounce whichever detector is armed, with the SAME rule for both, so the
  // conventional detector is not handicapped by a noisier output stage.
  bool activeRaw = (alarmMode == 0) ? curThresh : curModelRaw;
  leakStreak = activeRaw ? (leakStreak + 1) : 0;
  curAlarm   = (leakStreak >= CONFIRM_SAMPLES);

  bool warming   = (millis() < WARMUP_MS);
  bool assertOut = (curAlarm && !warming) || (testUntil && millis() < testUntil);
  digitalWrite(LED_ALARM, assertOut ? HIGH : LOW);
  digitalWrite(LED_SAFE,  assertOut ? LOW  : HIGH);
  digitalWrite(BUZZER_PIN, (assertOut && !muted) ? HIGH : LOW);

  if (sampleCount % 8 == 0) {
    Serial.printf("# AP ip=%s  clients=%d  hits=%lu  uptime=%lus  armed=%s\n",
                  WiFi.softAPIP().toString().c_str(),
                  WiFi.softAPgetStationNum(),
                  (unsigned long)httpHits,
                  (unsigned long)(millis() / 1000),
                  alarmMode ? "SNIFF" : "conventional");
  }

  if (warming)
    Serial.printf("# warming up, alarm suppressed, %lus left\n",
                  (unsigned long)((WARMUP_MS - millis()) / 1000));

  Serial.printf("%.4f,%.2f,%.2f,%.5f,%s,%.3f,%s,%s\n",
                curRsRo, lastTemp, lastRH, curSlope,
                curAlarm ? "LEAK" : "safe", curConf,
                curThresh ? "LEAK" : "safe",
                curComp   ? "LEAK" : "safe");
}
